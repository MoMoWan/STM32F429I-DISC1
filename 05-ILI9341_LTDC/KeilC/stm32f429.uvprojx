# Keil uVision project stm32f429.uvprojx, settings and files
target STM32F429ZI (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f429 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Utilities;..\StdPeriph_Lib_V1.7.1\CMSIS\Include;..\StdPeriph_Lib_V1.7.1\CMSIS\Device\Include;..\StdPeriph_Lib_V1.7.1\StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c
  group Startup
    ../User/: system_stm32f4xx.c
    ../StdPeriph_Lib_V1.7.1/CMSIS/Device/Source/arm/: startup_stm32f429_439xx.s
  group StdPeriph_Driver
    ../StdPeriph_Lib_V1.7.1/StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_dma.c stm32f4xx_spi.c stm32f4xx_dma2d.c stm32f4xx_ltdc.c stm32f4xx_fmc.c
  group Utilities
    ../Utilities/: stm32f4_delay.c stm32f4_led.c stm32f4_gpio.c stm32f4_dma.c stm32f4_fonts.c stm32f4_spi.c stm32f4_spi_dma.c stm32f4_ili9341_ltdc.c stm32f4_dma2d_graphic.c stm32f4_sdram.c
  group Readme
    ../Readme/: readme.txt
